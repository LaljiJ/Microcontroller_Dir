# Keil uVision project DS1307_RTC_I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: DS1307_RTC_I2C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c timer.c timer.h i2c_driver.h ds1307.h i2c_driver.c ds1307.c
