# Keil uVision project PortChecking.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: PortChecking +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led.c led.h main.c main.h timer.c timer.h
