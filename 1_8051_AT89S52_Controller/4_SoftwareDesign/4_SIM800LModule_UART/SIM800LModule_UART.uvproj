# Keil uVision project SIM800LModule_UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: SIM800LModule_UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c sim800l.c sim800l.h timer.c timer.h uart_driver.c uart_driver.h
